# Keil uVision project project_l0.uvprojx, settings and files
target at_start_f490 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F490RCT7 ArteryTek
  pack: ArteryTek.AT32F490_DFP.2.0.0
  cpu: IRAM(0x20000000,0x19800) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32f490_project_l0 +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F490RCT7,USE_STDPERIPH_DRIVER,AT_START_F490_V1,ARM_MATH_CM4
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\project\at32f490_board
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x19800
  scatter file: .\slib-w-xo.sct
  link misc: --symdefs=fir_filter_symbol.txt
  group user
    ../src/: at32f490_clock.c at32f490_int.c arm_fir_data.c math_helper.c main.c
  group bsp
    ../../../../project/at32f490_board/: at32f490_board.c
  group firmware
    ../../../../libraries/drivers/src/: at32f490_crm.c at32f490_usart.c at32f490_flash.c at32f490_gpio.c at32f490_misc.c at32f490_qspi.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f490.c
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f490.s
  group fir_filter
    ../src/: arm_fir_f32.c arm_fir_init_f32.c fir_coefficient.c fir_filter.c
  group readme
    ../: readme.txt
