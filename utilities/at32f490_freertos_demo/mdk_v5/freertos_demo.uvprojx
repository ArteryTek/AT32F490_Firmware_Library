# Keil uVision project freertos_demo.uvprojx, settings and files
target 490_freertos_demo_ac5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F490RCT7 ArteryTek
  pack: ArteryTek.AT32F490_DFP.2.0.0
  cpu: IRAM(0x20000000,0x19800) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 490_freertos_demo_ac5 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F490RCT7,USE_STDPERIPH_DRIVER,AT_START_F490_V1
  c include: ..\inc;..\..\..\libraries\drivers\inc;..\..\..\project\at32f490_board;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\rvds\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x19800
  group user
    ../src/: at32f490_clock.c at32f490_int.c main.c include_port.c
  group bsp
    ../../../project/at32f490_board/: at32f490_board.c
  group firmware
    ../../../libraries/drivers/src/: at32f490_acc.c at32f490_adc.c at32f490_can.c at32f490_crc.c at32f490_crm.c at32f490_debug.c at32f490_dma.c at32f490_ertc.c at32f490_exint.c at32f490_flash.c at32f490_gpio.c at32f490_i2c.c at32f490_misc.c at32f490_qspi.c at32f490_pwc.c at32f490_scfg.c at32f490_spi.c at32f490_tmr.c at32f490_usart.c at32f490_usb.c at32f490_wdt.c at32f490_wwdt.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/: system_at32f490.c
    ../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f490.s
  group freertos
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
  group readme
    ../: readme.txt
target 490_freertos_demo_ac6 (6160000::V6.16::ARMCLANG)
  device: AT32F490RCT7 ArteryTek
  pack: ArteryTek.AT32F490_DFP.2.0.0
  output: 490_freertos_demo_ac6 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F490RCT7,USE_STDPERIPH_DRIVER,AT_START_F490_V1
  c include: ..\inc;..\..\..\libraries\drivers\inc;..\..\..\project\at32f490_board;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\GCC\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x19800
