# Keil uVision project msc_only_fat32.uvprojx, settings and files
target msc_only_fat32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F490RCT7 ArteryTek
  pack: ArteryTek.AT32F490_DFP.2.0.0
  cpu: IRAM(0x20000000,0x19800) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: msc_only_fat32 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F490RCT7,USE_STDPERIPH_DRIVER,AT_START_F490_V1
  c include: ..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\at32f490_board;..\inc;..\..\..\..\..\..\middlewares\usb_drivers\inc;..\..\..\..\..\..\middlewares\usbh_class\usbh_msc;..\..\..\..\..\..\middlewares\3rd_party\fatfs\source
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x19800
  group user
    ../src/: at32f490_clock.c at32f490_int.c main.c usbh_user.c usbh_msc_diskio.c
  group bsp
    ../../../../../at32f490_board/: at32f490_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f490_acc.c at32f490_crm.c at32f490_exint.c at32f490_gpio.c at32f490_misc.c at32f490_qspi.c at32f490_pwc.c at32f490_scfg.c at32f490_usart.c at32f490_usb.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f490.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f490.s
  group usbh_driver
    ../../../../../../middlewares/usb_drivers/src/: usb_core.c usbh_core.c usbh_ctrl.c usbh_int.c
  group usbh_class
    ../../../../../../middlewares/usbh_class/usbh_msc/: usbh_msc_class.c usbh_msc_bot_scsi.c
  group fatfs
    ../../../../../../middlewares/3rd_party/fatfs/source/: ff.c
  group readme
    ../: readme.txt
