# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F490RCT7_v2 ArteryTek AT32F490RCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F490RCT7; USE_STDPERIPH_DRIVER; AT_START_F490_V1
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\at32f490_board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group bsp
    ../../../at32f490_board/: at32f490_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f490.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f490.c
  group firmware
    ../../../../libraries/drivers/src/: at32f490_acc.c at32f490_adc.c at32f490_can.c at32f490_crc.c at32f490_crm.c at32f490_debug.c at32f490_dma.c at32f490_ertc.c at32f490_exint.c at32f490_flash.c at32f490_gpio.c at32f490_i2c.c at32f490_misc.c at32f490_pwc.c at32f490_qspi.c at32f490_scfg.c at32f490_spi.c at32f490_tmr.c at32f490_usart.c at32f490_usb.c at32f490_wdt.c at32f490_wwdt.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f490_clock.c at32f490_int.c main.c
