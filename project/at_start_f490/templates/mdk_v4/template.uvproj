# Keil uVision project template.uvproj, settings and files
target tempate (ARM-ADS)
  device: AT32F490RCT7 ArteryTek
  output: Template +hex
  c flags: Optim=1
  c define: AT32F490RCT7,USE_STDPERIPH_DRIVER,AT_START_F490_V1
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\at32f490_board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group user
    ../src/: at32f490_clock.c at32f490_int.c main.c
  group bsp
    ../../../at32f490_board/: at32f490_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f490.c
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f490.s
  group firmware
    ../../../../libraries/drivers/src/: at32f490_acc.c at32f490_adc.c at32f490_can.c at32f490_crc.c at32f490_crm.c at32f490_debug.c at32f490_dma.c at32f490_ertc.c at32f490_exint.c at32f490_flash.c at32f490_gpio.c at32f490_i2c.c at32f490_misc.c at32f490_pwc.c at32f490_qspi.c at32f490_scfg.c at32f490_spi.c at32f490_tmr.c at32f490_usart.c at32f490_usb.c at32f490_wdt.c at32f490_wwdt.c
  group readme
    ../: readme.txt
